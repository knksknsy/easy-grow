## main/Kconfig.projbuild
```kconfig
menu "Easy Configuration"

config CHANNEL
    int "Channel"
    range 1 13
    default 1

endmenu
```
